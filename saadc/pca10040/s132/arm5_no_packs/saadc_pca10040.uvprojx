# Keil uVision project saadc_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF52832 NRF52 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 CONFIG_GPIO_AS_PINRESET NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 BSP_DEFINES_ONLY
  c include: ..\..\..\config\saadc_pca10040;..\..\..\config;..\.\..\..\components;..\..\..\..\components\boards;..\..\..\..\components\drivers_nrf\common;..\..\..\..\components\drivers_nrf\delay;..\..\..\..\components\drivers_nrf\hal;..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\components\drivers_nrf\timer;..\..\..\..\components\drivers_nrf\uart;..\..\..\..\components\libraries\bsp;..\..\..\..\components\libraries\log;..\..\..\..\components\libraries\log\src;..\..\..\..\components\libraries\scheduler;..\..\..\..\components\libraries\timer;..\..\..\..\components\libraries\util;..\..\..\..\components\toolchain;..\..\..;..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DNRF52832,-DNRF52,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DBSP_DEFINES_ONLY
  asm include: ..\..\..\config\saadc_pca10040;..\..\..\config;..\..\..\..\components;..\..\..\..\components\boards;..\..\..\..\components\drivers_nrf\common;..\..\..\..\components\drivers_nrf\delay;..\..\..\..\components\drivers_nrf\hal;..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\components\drivers_nrf\timer;..\..\..\..\components\drivers_nrf\uart;..\..\..\..\components\libraries\bsp;..\..\..\..\components\libraries\log;..\..\..\..\components\libraries\log\src;..\..\..\..\components\libraries\util;..\..\..\..\components\toolchain;..\..\..;..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../components/boards/: boards.c
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    ../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../components/drivers_nrf/hal/: nrf_saadc.c
  group nRF_Libraries
    ../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
  group nRF_Log
    ../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group timer
    ../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c app_timer_ble_gzll.c app_timer_rtx.c
  group scheduler
    ../../../../components/libraries/scheduler/: app_scheduler.c app_scheduler_serconn.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
